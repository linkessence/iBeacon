# IAR project BNotification.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=2048; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; CC2540_MINIDK
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: HAL\include; HAL\target\CC2541MiniEB; OSAL\include; BLE\include; BLE\controller\include; Profiles\Roles; BLE\host; BLE\hci; SADDR; Common\cc2540; Common\npi
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: Config\ti_51ew_cc2540b.xcl
configuration Release (8051, debug)
  as the first configuration, except:
  ICC8051.CCOptLevel: 3
  group App
    App/: BNotification.c BNotification.h BNotification_discovery.c BNotification_main.c OSAL_BNotification.c
  group BLE/Host
    BLE/host/: gatt_uuid.c
  group Common
    Common/cc2540/: OnBoard.c OnBoard.h
  group Config
    config/: buildComponents.cfg buildConfig.cfg ti_51ew_cc2540b.xcl
  group HAL/Common
    HAL/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    HAL/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2541MiniEB/Config
    HAL/target/CC2541MiniEB/: hal_board_cfg.h
  group HAL/Target/CC2541MiniEB/Driver
    HAL/target/CC2541MiniEB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2541MiniEB/Include
    HAL/target/CC2541MiniEB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group Include
    BLE/include/: att.h bcomdef.h gap.h gapgattserver.h gatt.h gatt_profile_uuid.h gatt_uuid.h gattservapp.h hci.h l2cap.h sm.h
    BLE/hci/: hci_data.h hci_event.h hci_tl.h
    BLE/host/: linkdb.h
    BLE/controller/include/: ll.h ll_math.h ll_sleep.h ll_timer2.h phy.h phy_image.h
  group Libs
    BLE/Libs/: CC2541_BLE.lib CC254x_BLE_HCI_TL_None.lib
  group OSAL/CC2540
    OSAL/mcu/cc2540/: osal_snv.c
  group OSAL/Common
    OSAL/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group OSAL/Include
    OSAL/include/: comdef.h OSAL.h osal_bufmgr.h osal_cbTimer.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h osal_snv.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
  group Profiles/Roles
    Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
  group SADDR/Include
    SADDR/: saddr.h
